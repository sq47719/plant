# Keil uVision project Template.uvprojx, settings and files
target Template (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\103C8T6_ADC1;..\SYSTEM\key;..\SYSTEM\103C8T6_OLED4;..\SYSTEM\Beep_Led_Relay;..\SYSTEM\Control_Report_To_Police;..\SYSTEM\103C8T6_ADC2;..\SYSTEM\103C8T6_DHT11;..\SYSTEM\103C8T6_LCD1602;..\SYSTEM\103C8T6_HX711;..\SYSTEM\103C8T6_HSR04;..\SYSTEM\103C8T6_TIME2;..\SYSTEM\103C8T6_GY906;..\SYSTEM\103C8T6_TIME1;..\SYSTEM\103C8T6_TIME3;..\SYSTEM\103C8T6_TIME4;..\SYSTEM\103C8T6_UART1;..\SYSTEM\103C8T6_GPS_ATGM336;..\SYSTEM\103C8T6_UART2;..\SYSTEM\103C8T6_UART3;..\SYSTEM\103C8T6_ADXL345;..\SYSTEM\103C8T6_ADXL345;..\SYSTEM\103C8T6_IIC;..\SYSTEM\103C8T6_DS1302;..\SYSTEM\103C8T6_RC522;..\SYSTEM\103C8T6_SPI;..\SYSTEM\103C8T6_ASR01;..\SYSTEM\103C8T6_E18-D80;..\SYSTEM\103C8T6_JR6001;..\SYSTEM\103C8T6_OLED7;..\SYSTEM\103C8T6_ULN2003;..\SYSTEM\103C8T6_NRF24L01;..\SYSTEM\103C8T6_SERVOR;..\SYSTEM\103C8T6_TCS34725_Colour;..\SYSTEM\103C8T6_SIM900A;..\SYSTEM\103C8T6_ZIGBEE;..\SYSTEM\103C8T6_RTC;..\SYSTEM\103C8T6_ADC1;..\ONENET\device;..\ONENET\MQTT;..\ONENET\onenet\inc;..\ONENET\device\inc;..\SYSTEM\103C8T6_RTC;..\SYSTEM\103C8T6_L298N;..\ALi_IOT;..\ALi_IOT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/key/: key.c
    ../SYSTEM/103C8T6_OLED4/: OLED_I2C.c
    ../SYSTEM/Beep_Led_Relay/: Beep_Led_Relay.c
    ../SYSTEM/Control_Report_To_Police/: Control_Report_To_Police.c
    ../SYSTEM/103C8T6_DHT11/: dht11.c
    ../SYSTEM/103C8T6_TIME3/: timer3.c
    ../SYSTEM/103C8T6_TIME4/: timer4.c
    ../SYSTEM/103C8T6_UART1/: usart .c
    ../SYSTEM/103C8T6_UART2/: usart2.c
    ../SYSTEM/103C8T6_UART3/: usart3.c
    ../SYSTEM/103C8T6_IIC/: myiic.c
    ../SYSTEM/103C8T6_SPI/: spi.c
    ../SYSTEM/103C8T6_ADC1/: adc.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group ONENET
    ../ONENET/device/src/: esp8266.c
    ../ONENET/MQTT/: MqttKit.c
    ../ONENET/onenet/src/: base64.c hmac_sha1.c onenet.c
  group ALi_IOT
    ../ALi_IOT/: mqtt.c wifi.c utils_hmac.c utils_md5.c utils_sha1.c
